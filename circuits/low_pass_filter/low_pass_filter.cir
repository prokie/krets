* Low Pass filter
V1 in 0 1 AC 1
R1 in out 1000
C1 out 0 0.001

.control
ac lin 1 1000 1000
save all
print all
.endc
