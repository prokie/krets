V4 1 0 3
R3 1 2 1
I2 2 1 2
R1 2 0 1
