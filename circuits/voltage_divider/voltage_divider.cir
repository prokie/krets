* Voltage Divider

V1 in 0 1
R1 in out 1000
R2 out 0 2000

.control
ac lin 1 1000 1000
save all
print all
.endc
