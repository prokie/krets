% N-sized resistor ladder
V1 1 0 1
R1 1 2 1000
R2 2 3 1000
R3 3 4 1000
R4 4 5 1000
R5 5 6 1000
R6 6 7 1000
R7 7 8 1000
R8 8 9 1000
R9 9 10 1000
R10 10 11 1000
R11 11 12 1000
R12 12 13 1000
R13 13 14 1000
R14 14 15 1000
R15 15 16 1000
R16 16 17 1000
R17 17 18 1000
R18 18 19 1000
R19 19 20 1000
R20 20 21 1000
R21 21 22 1000
R22 22 23 1000
R23 23 24 1000
R24 24 25 1000
R25 25 26 1000
R26 26 27 1000
R27 27 28 1000
R28 28 29 1000
R29 29 30 1000
R30 30 31 1000
R31 31 32 1000
R32 32 33 1000
R33 33 34 1000
R34 34 35 1000
R35 35 36 1000
R36 36 37 1000
R37 37 38 1000
R38 38 39 1000
R39 39 40 1000
R40 40 41 1000
R41 41 42 1000
R42 42 43 1000
R43 43 44 1000
R44 44 45 1000
R45 45 46 1000
R46 46 47 1000
R47 47 48 1000
R48 48 49 1000
R49 49 50 1000
R50 50 51 1000
R51 51 52 1000
R52 52 53 1000
R53 53 54 1000
R54 54 55 1000
R55 55 56 1000
R56 56 57 1000
R57 57 58 1000
R58 58 59 1000
R59 59 60 1000
R60 60 61 1000
R61 61 62 1000
R62 62 63 1000
R63 63 64 1000
R64 64 65 1000
R65 65 66 1000
R66 66 67 1000
R67 67 68 1000
R68 68 69 1000
R69 69 70 1000
R70 70 71 1000
R71 71 72 1000
R72 72 73 1000
R73 73 74 1000
R74 74 75 1000
R75 75 76 1000
R76 76 77 1000
R77 77 78 1000
R78 78 79 1000
R79 79 80 1000
R80 80 81 1000
R81 81 82 1000
R82 82 83 1000
R83 83 84 1000
R84 84 85 1000
R85 85 86 1000
R86 86 87 1000
R87 87 88 1000
R88 88 89 1000
R89 89 90 1000
R90 90 91 1000
R91 91 92 1000
R92 92 93 1000
R93 93 94 1000
R94 94 95 1000
R95 95 96 1000
R96 96 97 1000
R97 97 98 1000
R98 98 99 1000
R99 99 100 1000
R100 100 101 1000
R101 101 102 1000
R102 102 103 1000
R103 103 104 1000
R104 104 105 1000
R105 105 106 1000
R106 106 107 1000
R107 107 108 1000
R108 108 109 1000
R109 109 110 1000
R110 110 111 1000
R111 111 112 1000
R112 112 113 1000
R113 113 114 1000
R114 114 115 1000
R115 115 116 1000
R116 116 117 1000
R117 117 118 1000
R118 118 119 1000
R119 119 120 1000
R120 120 121 1000
R121 121 122 1000
R122 122 123 1000
R123 123 124 1000
R124 124 125 1000
R125 125 126 1000
R126 126 127 1000
R127 127 128 1000
R128 128 129 1000
R129 129 130 1000
R130 130 131 1000
R131 131 132 1000
R132 132 133 1000
R133 133 134 1000
R134 134 135 1000
R135 135 136 1000
R136 136 137 1000
R137 137 138 1000
R138 138 139 1000
R139 139 140 1000
R140 140 141 1000
R141 141 142 1000
R142 142 143 1000
R143 143 144 1000
R144 144 145 1000
R145 145 146 1000
R146 146 147 1000
R147 147 148 1000
R148 148 149 1000
R149 149 150 1000
R150 150 151 1000
R151 151 152 1000
R152 152 153 1000
R153 153 154 1000
R154 154 155 1000
R155 155 156 1000
R156 156 157 1000
R157 157 158 1000
R158 158 159 1000
R159 159 160 1000
R160 160 161 1000
R161 161 162 1000
R162 162 163 1000
R163 163 164 1000
R164 164 165 1000
R165 165 166 1000
R166 166 167 1000
R167 167 168 1000
R168 168 169 1000
R169 169 170 1000
R170 170 171 1000
R171 171 172 1000
R172 172 173 1000
R173 173 174 1000
R174 174 175 1000
R175 175 176 1000
R176 176 177 1000
R177 177 178 1000
R178 178 179 1000
R179 179 180 1000
R180 180 181 1000
R181 181 182 1000
R182 182 183 1000
R183 183 184 1000
R184 184 185 1000
R185 185 186 1000
R186 186 187 1000
R187 187 188 1000
R188 188 189 1000
R189 189 190 1000
R190 190 191 1000
R191 191 192 1000
R192 192 193 1000
R193 193 194 1000
R194 194 195 1000
R195 195 196 1000
R196 196 197 1000
R197 197 198 1000
R198 198 199 1000
R199 199 200 1000
R200 200 201 1000
R201 201 202 1000
R202 202 203 1000
R203 203 204 1000
R204 204 205 1000
R205 205 206 1000
R206 206 207 1000
R207 207 208 1000
R208 208 209 1000
R209 209 210 1000
R210 210 211 1000
R211 211 212 1000
R212 212 213 1000
R213 213 214 1000
R214 214 215 1000
R215 215 216 1000
R216 216 217 1000
R217 217 218 1000
R218 218 219 1000
R219 219 220 1000
R220 220 221 1000
R221 221 222 1000
R222 222 223 1000
R223 223 224 1000
R224 224 225 1000
R225 225 226 1000
R226 226 227 1000
R227 227 228 1000
R228 228 229 1000
R229 229 230 1000
R230 230 231 1000
R231 231 232 1000
R232 232 233 1000
R233 233 234 1000
R234 234 235 1000
R235 235 236 1000
R236 236 237 1000
R237 237 238 1000
R238 238 239 1000
R239 239 240 1000
R240 240 241 1000
R241 241 242 1000
R242 242 243 1000
R243 243 244 1000
R244 244 245 1000
R245 245 246 1000
R246 246 247 1000
R247 247 248 1000
R248 248 249 1000
R249 249 250 1000
R250 250 251 1000
R251 251 252 1000
R252 252 253 1000
R253 253 254 1000
R254 254 255 1000
R255 255 256 1000
R256 256 257 1000
R257 257 258 1000
R258 258 259 1000
R259 259 260 1000
R260 260 261 1000
R261 261 262 1000
R262 262 263 1000
R263 263 264 1000
R264 264 265 1000
R265 265 266 1000
R266 266 267 1000
R267 267 268 1000
R268 268 269 1000
R269 269 270 1000
R270 270 271 1000
R271 271 272 1000
R272 272 273 1000
R273 273 274 1000
R274 274 275 1000
R275 275 276 1000
R276 276 277 1000
R277 277 278 1000
R278 278 279 1000
R279 279 280 1000
R280 280 281 1000
R281 281 282 1000
R282 282 283 1000
R283 283 284 1000
R284 284 285 1000
R285 285 286 1000
R286 286 287 1000
R287 287 288 1000
R288 288 289 1000
R289 289 290 1000
R290 290 291 1000
R291 291 292 1000
R292 292 293 1000
R293 293 294 1000
R294 294 295 1000
R295 295 296 1000
R296 296 297 1000
R297 297 298 1000
R298 298 299 1000
R299 299 300 1000
R300 300 301 1000
R301 301 302 1000
R302 302 303 1000
R303 303 304 1000
R304 304 305 1000
R305 305 306 1000
R306 306 307 1000
R307 307 308 1000
R308 308 309 1000
R309 309 310 1000
R310 310 311 1000
R311 311 312 1000
R312 312 313 1000
R313 313 314 1000
R314 314 315 1000
R315 315 316 1000
R316 316 317 1000
R317 317 318 1000
R318 318 319 1000
R319 319 320 1000
R320 320 321 1000
R321 321 322 1000
R322 322 323 1000
R323 323 324 1000
R324 324 325 1000
R325 325 326 1000
R326 326 327 1000
R327 327 328 1000
R328 328 329 1000
R329 329 330 1000
R330 330 331 1000
R331 331 332 1000
R332 332 333 1000
R333 333 334 1000
R334 334 335 1000
R335 335 336 1000
R336 336 337 1000
R337 337 338 1000
R338 338 339 1000
R339 339 340 1000
R340 340 341 1000
R341 341 342 1000
R342 342 343 1000
R343 343 344 1000
R344 344 345 1000
R345 345 346 1000
R346 346 347 1000
R347 347 348 1000
R348 348 349 1000
R349 349 350 1000
R350 350 351 1000
R351 351 352 1000
R352 352 353 1000
R353 353 354 1000
R354 354 355 1000
R355 355 356 1000
R356 356 357 1000
R357 357 358 1000
R358 358 359 1000
R359 359 360 1000
R360 360 361 1000
R361 361 362 1000
R362 362 363 1000
R363 363 364 1000
R364 364 365 1000
R365 365 366 1000
R366 366 367 1000
R367 367 368 1000
R368 368 369 1000
R369 369 370 1000
R370 370 371 1000
R371 371 372 1000
R372 372 373 1000
R373 373 374 1000
R374 374 375 1000
R375 375 376 1000
R376 376 377 1000
R377 377 378 1000
R378 378 379 1000
R379 379 380 1000
R380 380 381 1000
R381 381 382 1000
R382 382 383 1000
R383 383 384 1000
R384 384 385 1000
R385 385 386 1000
R386 386 387 1000
R387 387 388 1000
R388 388 389 1000
R389 389 390 1000
R390 390 391 1000
R391 391 392 1000
R392 392 393 1000
R393 393 394 1000
R394 394 395 1000
R395 395 396 1000
R396 396 397 1000
R397 397 398 1000
R398 398 399 1000
R399 399 400 1000
R400 400 401 1000
R401 401 402 1000
R402 402 403 1000
R403 403 404 1000
R404 404 405 1000
R405 405 406 1000
R406 406 407 1000
R407 407 408 1000
R408 408 409 1000
R409 409 410 1000
R410 410 411 1000
R411 411 412 1000
R412 412 413 1000
R413 413 414 1000
R414 414 415 1000
R415 415 416 1000
R416 416 417 1000
R417 417 418 1000
R418 418 419 1000
R419 419 420 1000
R420 420 421 1000
R421 421 422 1000
R422 422 423 1000
R423 423 424 1000
R424 424 425 1000
R425 425 426 1000
R426 426 427 1000
R427 427 428 1000
R428 428 429 1000
R429 429 430 1000
R430 430 431 1000
R431 431 432 1000
R432 432 433 1000
R433 433 434 1000
R434 434 435 1000
R435 435 436 1000
R436 436 437 1000
R437 437 438 1000
R438 438 439 1000
R439 439 440 1000
R440 440 441 1000
R441 441 442 1000
R442 442 443 1000
R443 443 444 1000
R444 444 445 1000
R445 445 446 1000
R446 446 447 1000
R447 447 448 1000
R448 448 449 1000
R449 449 450 1000
R450 450 451 1000
R451 451 452 1000
R452 452 453 1000
R453 453 454 1000
R454 454 455 1000
R455 455 456 1000
R456 456 457 1000
R457 457 458 1000
R458 458 459 1000
R459 459 460 1000
R460 460 461 1000
R461 461 462 1000
R462 462 463 1000
R463 463 464 1000
R464 464 465 1000
R465 465 466 1000
R466 466 467 1000
R467 467 468 1000
R468 468 469 1000
R469 469 470 1000
R470 470 471 1000
R471 471 472 1000
R472 472 473 1000
R473 473 474 1000
R474 474 475 1000
R475 475 476 1000
R476 476 477 1000
R477 477 478 1000
R478 478 479 1000
R479 479 480 1000
R480 480 481 1000
R481 481 482 1000
R482 482 483 1000
R483 483 484 1000
R484 484 485 1000
R485 485 486 1000
R486 486 487 1000
R487 487 488 1000
R488 488 489 1000
R489 489 490 1000
R490 490 491 1000
R491 491 492 1000
R492 492 493 1000
R493 493 494 1000
R494 494 495 1000
R495 495 496 1000
R496 496 497 1000
R497 497 498 1000
R498 498 499 1000
R499 499 500 1000
R500 500 501 1000
R501 501 502 1000
R502 502 503 1000
R503 503 504 1000
R504 504 505 1000
R505 505 506 1000
R506 506 507 1000
R507 507 508 1000
R508 508 509 1000
R509 509 510 1000
R510 510 511 1000
R511 511 512 1000
R512 512 513 1000
R513 513 514 1000
R514 514 515 1000
R515 515 516 1000
R516 516 517 1000
R517 517 518 1000
R518 518 519 1000
R519 519 520 1000
R520 520 521 1000
R521 521 522 1000
R522 522 523 1000
R523 523 524 1000
R524 524 525 1000
R525 525 526 1000
R526 526 527 1000
R527 527 528 1000
R528 528 529 1000
R529 529 530 1000
R530 530 531 1000
R531 531 532 1000
R532 532 533 1000
R533 533 534 1000
R534 534 535 1000
R535 535 536 1000
R536 536 537 1000
R537 537 538 1000
R538 538 539 1000
R539 539 540 1000
R540 540 541 1000
R541 541 542 1000
R542 542 543 1000
R543 543 544 1000
R544 544 545 1000
R545 545 546 1000
R546 546 547 1000
R547 547 548 1000
R548 548 549 1000
R549 549 550 1000
R550 550 551 1000
R551 551 552 1000
R552 552 553 1000
R553 553 554 1000
R554 554 555 1000
R555 555 556 1000
R556 556 557 1000
R557 557 558 1000
R558 558 559 1000
R559 559 560 1000
R560 560 561 1000
R561 561 562 1000
R562 562 563 1000
R563 563 564 1000
R564 564 565 1000
R565 565 566 1000
R566 566 567 1000
R567 567 568 1000
R568 568 569 1000
R569 569 570 1000
R570 570 571 1000
R571 571 572 1000
R572 572 573 1000
R573 573 574 1000
R574 574 575 1000
R575 575 576 1000
R576 576 577 1000
R577 577 578 1000
R578 578 579 1000
R579 579 580 1000
R580 580 581 1000
R581 581 582 1000
R582 582 583 1000
R583 583 584 1000
R584 584 585 1000
R585 585 586 1000
R586 586 587 1000
R587 587 588 1000
R588 588 589 1000
R589 589 590 1000
R590 590 591 1000
R591 591 592 1000
R592 592 593 1000
R593 593 594 1000
R594 594 595 1000
R595 595 596 1000
R596 596 597 1000
R597 597 598 1000
R598 598 599 1000
R599 599 600 1000
R600 600 601 1000
R601 601 602 1000
R602 602 603 1000
R603 603 604 1000
R604 604 605 1000
R605 605 606 1000
R606 606 607 1000
R607 607 608 1000
R608 608 609 1000
R609 609 610 1000
R610 610 611 1000
R611 611 612 1000
R612 612 613 1000
R613 613 614 1000
R614 614 615 1000
R615 615 616 1000
R616 616 617 1000
R617 617 618 1000
R618 618 619 1000
R619 619 620 1000
R620 620 621 1000
R621 621 622 1000
R622 622 623 1000
R623 623 624 1000
R624 624 625 1000
R625 625 626 1000
R626 626 627 1000
R627 627 628 1000
R628 628 629 1000
R629 629 630 1000
R630 630 631 1000
R631 631 632 1000
R632 632 633 1000
R633 633 634 1000
R634 634 635 1000
R635 635 636 1000
R636 636 637 1000
R637 637 638 1000
R638 638 639 1000
R639 639 640 1000
R640 640 641 1000
R641 641 642 1000
R642 642 643 1000
R643 643 644 1000
R644 644 645 1000
R645 645 646 1000
R646 646 647 1000
R647 647 648 1000
R648 648 649 1000
R649 649 650 1000
R650 650 651 1000
R651 651 652 1000
R652 652 653 1000
R653 653 654 1000
R654 654 655 1000
R655 655 656 1000
R656 656 657 1000
R657 657 658 1000
R658 658 659 1000
R659 659 660 1000
R660 660 661 1000
R661 661 662 1000
R662 662 663 1000
R663 663 664 1000
R664 664 665 1000
R665 665 666 1000
R666 666 667 1000
R667 667 668 1000
R668 668 669 1000
R669 669 670 1000
R670 670 671 1000
R671 671 672 1000
R672 672 673 1000
R673 673 674 1000
R674 674 675 1000
R675 675 676 1000
R676 676 677 1000
R677 677 678 1000
R678 678 679 1000
R679 679 680 1000
R680 680 681 1000
R681 681 682 1000
R682 682 683 1000
R683 683 684 1000
R684 684 685 1000
R685 685 686 1000
R686 686 687 1000
R687 687 688 1000
R688 688 689 1000
R689 689 690 1000
R690 690 691 1000
R691 691 692 1000
R692 692 693 1000
R693 693 694 1000
R694 694 695 1000
R695 695 696 1000
R696 696 697 1000
R697 697 698 1000
R698 698 699 1000
R699 699 700 1000
R700 700 701 1000
R701 701 702 1000
R702 702 703 1000
R703 703 704 1000
R704 704 705 1000
R705 705 706 1000
R706 706 707 1000
R707 707 708 1000
R708 708 709 1000
R709 709 710 1000
R710 710 711 1000
R711 711 712 1000
R712 712 713 1000
R713 713 714 1000
R714 714 715 1000
R715 715 716 1000
R716 716 717 1000
R717 717 718 1000
R718 718 719 1000
R719 719 720 1000
R720 720 721 1000
R721 721 722 1000
R722 722 723 1000
R723 723 724 1000
R724 724 725 1000
R725 725 726 1000
R726 726 727 1000
R727 727 728 1000
R728 728 729 1000
R729 729 730 1000
R730 730 731 1000
R731 731 732 1000
R732 732 733 1000
R733 733 734 1000
R734 734 735 1000
R735 735 736 1000
R736 736 737 1000
R737 737 738 1000
R738 738 739 1000
R739 739 740 1000
R740 740 741 1000
R741 741 742 1000
R742 742 743 1000
R743 743 744 1000
R744 744 745 1000
R745 745 746 1000
R746 746 747 1000
R747 747 748 1000
R748 748 749 1000
R749 749 750 1000
R750 750 751 1000
R751 751 752 1000
R752 752 753 1000
R753 753 754 1000
R754 754 755 1000
R755 755 756 1000
R756 756 757 1000
R757 757 758 1000
R758 758 759 1000
R759 759 760 1000
R760 760 761 1000
R761 761 762 1000
R762 762 763 1000
R763 763 764 1000
R764 764 765 1000
R765 765 766 1000
R766 766 767 1000
R767 767 768 1000
R768 768 769 1000
R769 769 770 1000
R770 770 771 1000
R771 771 772 1000
R772 772 773 1000
R773 773 774 1000
R774 774 775 1000
R775 775 776 1000
R776 776 777 1000
R777 777 778 1000
R778 778 779 1000
R779 779 780 1000
R780 780 781 1000
R781 781 782 1000
R782 782 783 1000
R783 783 784 1000
R784 784 785 1000
R785 785 786 1000
R786 786 787 1000
R787 787 788 1000
R788 788 789 1000
R789 789 790 1000
R790 790 791 1000
R791 791 792 1000
R792 792 793 1000
R793 793 794 1000
R794 794 795 1000
R795 795 796 1000
R796 796 797 1000
R797 797 798 1000
R798 798 799 1000
R799 799 800 1000
R800 800 801 1000
R801 801 802 1000
R802 802 803 1000
R803 803 804 1000
R804 804 805 1000
R805 805 806 1000
R806 806 807 1000
R807 807 808 1000
R808 808 809 1000
R809 809 810 1000
R810 810 811 1000
R811 811 812 1000
R812 812 813 1000
R813 813 814 1000
R814 814 815 1000
R815 815 816 1000
R816 816 817 1000
R817 817 818 1000
R818 818 819 1000
R819 819 820 1000
R820 820 821 1000
R821 821 822 1000
R822 822 823 1000
R823 823 824 1000
R824 824 825 1000
R825 825 826 1000
R826 826 827 1000
R827 827 828 1000
R828 828 829 1000
R829 829 830 1000
R830 830 831 1000
R831 831 832 1000
R832 832 833 1000
R833 833 834 1000
R834 834 835 1000
R835 835 836 1000
R836 836 837 1000
R837 837 838 1000
R838 838 839 1000
R839 839 840 1000
R840 840 841 1000
R841 841 842 1000
R842 842 843 1000
R843 843 844 1000
R844 844 845 1000
R845 845 846 1000
R846 846 847 1000
R847 847 848 1000
R848 848 849 1000
R849 849 850 1000
R850 850 851 1000
R851 851 852 1000
R852 852 853 1000
R853 853 854 1000
R854 854 855 1000
R855 855 856 1000
R856 856 857 1000
R857 857 858 1000
R858 858 859 1000
R859 859 860 1000
R860 860 861 1000
R861 861 862 1000
R862 862 863 1000
R863 863 864 1000
R864 864 865 1000
R865 865 866 1000
R866 866 867 1000
R867 867 868 1000
R868 868 869 1000
R869 869 870 1000
R870 870 871 1000
R871 871 872 1000
R872 872 873 1000
R873 873 874 1000
R874 874 875 1000
R875 875 876 1000
R876 876 877 1000
R877 877 878 1000
R878 878 879 1000
R879 879 880 1000
R880 880 881 1000
R881 881 882 1000
R882 882 883 1000
R883 883 884 1000
R884 884 885 1000
R885 885 886 1000
R886 886 887 1000
R887 887 888 1000
R888 888 889 1000
R889 889 890 1000
R890 890 891 1000
R891 891 892 1000
R892 892 893 1000
R893 893 894 1000
R894 894 895 1000
R895 895 896 1000
R896 896 897 1000
R897 897 898 1000
R898 898 899 1000
R899 899 900 1000
R900 900 901 1000
R901 901 902 1000
R902 902 903 1000
R903 903 904 1000
R904 904 905 1000
R905 905 906 1000
R906 906 907 1000
R907 907 908 1000
R908 908 909 1000
R909 909 910 1000
R910 910 911 1000
R911 911 912 1000
R912 912 913 1000
R913 913 914 1000
R914 914 915 1000
R915 915 916 1000
R916 916 917 1000
R917 917 918 1000
R918 918 919 1000
R919 919 920 1000
R920 920 921 1000
R921 921 922 1000
R922 922 923 1000
R923 923 924 1000
R924 924 925 1000
R925 925 926 1000
R926 926 927 1000
R927 927 928 1000
R928 928 929 1000
R929 929 930 1000
R930 930 931 1000
R931 931 932 1000
R932 932 933 1000
R933 933 934 1000
R934 934 935 1000
R935 935 936 1000
R936 936 937 1000
R937 937 938 1000
R938 938 939 1000
R939 939 940 1000
R940 940 941 1000
R941 941 942 1000
R942 942 943 1000
R943 943 944 1000
R944 944 945 1000
R945 945 946 1000
R946 946 947 1000
R947 947 948 1000
R948 948 949 1000
R949 949 950 1000
R950 950 951 1000
R951 951 952 1000
R952 952 953 1000
R953 953 954 1000
R954 954 955 1000
R955 955 956 1000
R956 956 957 1000
R957 957 958 1000
R958 958 959 1000
R959 959 960 1000
R960 960 961 1000
R961 961 962 1000
R962 962 963 1000
R963 963 964 1000
R964 964 965 1000
R965 965 966 1000
R966 966 967 1000
R967 967 968 1000
R968 968 969 1000
R969 969 970 1000
R970 970 971 1000
R971 971 972 1000
R972 972 973 1000
R973 973 974 1000
R974 974 975 1000
R975 975 976 1000
R976 976 977 1000
R977 977 978 1000
R978 978 979 1000
R979 979 980 1000
R980 980 981 1000
R981 981 982 1000
R982 982 983 1000
R983 983 984 1000
R984 984 985 1000
R985 985 986 1000
R986 986 987 1000
R987 987 988 1000
R988 988 989 1000
R989 989 990 1000
R990 990 991 1000
R991 991 992 1000
R992 992 993 1000
R993 993 994 1000
R994 994 995 1000
R995 995 996 1000
R996 996 997 1000
R997 997 998 1000
R998 998 999 1000
R999 999 1000 1000
R1000 1000 0 1000

.control
rusage
op
save all
print all
rusage
quit
.endc
