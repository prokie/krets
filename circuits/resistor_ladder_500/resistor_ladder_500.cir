% N-sized resistor ladder
V1 1 0 1
R1 1 2 1000
R2 2 3 1000
R3 3 4 1000
R4 4 5 1000
R5 5 6 1000
R6 6 7 1000
R7 7 8 1000
R8 8 9 1000
R9 9 10 1000
R10 10 11 1000
R11 11 12 1000
R12 12 13 1000
R13 13 14 1000
R14 14 15 1000
R15 15 16 1000
R16 16 17 1000
R17 17 18 1000
R18 18 19 1000
R19 19 20 1000
R20 20 21 1000
R21 21 22 1000
R22 22 23 1000
R23 23 24 1000
R24 24 25 1000
R25 25 26 1000
R26 26 27 1000
R27 27 28 1000
R28 28 29 1000
R29 29 30 1000
R30 30 31 1000
R31 31 32 1000
R32 32 33 1000
R33 33 34 1000
R34 34 35 1000
R35 35 36 1000
R36 36 37 1000
R37 37 38 1000
R38 38 39 1000
R39 39 40 1000
R40 40 41 1000
R41 41 42 1000
R42 42 43 1000
R43 43 44 1000
R44 44 45 1000
R45 45 46 1000
R46 46 47 1000
R47 47 48 1000
R48 48 49 1000
R49 49 50 1000
R50 50 51 1000
R51 51 52 1000
R52 52 53 1000
R53 53 54 1000
R54 54 55 1000
R55 55 56 1000
R56 56 57 1000
R57 57 58 1000
R58 58 59 1000
R59 59 60 1000
R60 60 61 1000
R61 61 62 1000
R62 62 63 1000
R63 63 64 1000
R64 64 65 1000
R65 65 66 1000
R66 66 67 1000
R67 67 68 1000
R68 68 69 1000
R69 69 70 1000
R70 70 71 1000
R71 71 72 1000
R72 72 73 1000
R73 73 74 1000
R74 74 75 1000
R75 75 76 1000
R76 76 77 1000
R77 77 78 1000
R78 78 79 1000
R79 79 80 1000
R80 80 81 1000
R81 81 82 1000
R82 82 83 1000
R83 83 84 1000
R84 84 85 1000
R85 85 86 1000
R86 86 87 1000
R87 87 88 1000
R88 88 89 1000
R89 89 90 1000
R90 90 91 1000
R91 91 92 1000
R92 92 93 1000
R93 93 94 1000
R94 94 95 1000
R95 95 96 1000
R96 96 97 1000
R97 97 98 1000
R98 98 99 1000
R99 99 100 1000
R100 100 101 1000
R101 101 102 1000
R102 102 103 1000
R103 103 104 1000
R104 104 105 1000
R105 105 106 1000
R106 106 107 1000
R107 107 108 1000
R108 108 109 1000
R109 109 110 1000
R110 110 111 1000
R111 111 112 1000
R112 112 113 1000
R113 113 114 1000
R114 114 115 1000
R115 115 116 1000
R116 116 117 1000
R117 117 118 1000
R118 118 119 1000
R119 119 120 1000
R120 120 121 1000
R121 121 122 1000
R122 122 123 1000
R123 123 124 1000
R124 124 125 1000
R125 125 126 1000
R126 126 127 1000
R127 127 128 1000
R128 128 129 1000
R129 129 130 1000
R130 130 131 1000
R131 131 132 1000
R132 132 133 1000
R133 133 134 1000
R134 134 135 1000
R135 135 136 1000
R136 136 137 1000
R137 137 138 1000
R138 138 139 1000
R139 139 140 1000
R140 140 141 1000
R141 141 142 1000
R142 142 143 1000
R143 143 144 1000
R144 144 145 1000
R145 145 146 1000
R146 146 147 1000
R147 147 148 1000
R148 148 149 1000
R149 149 150 1000
R150 150 151 1000
R151 151 152 1000
R152 152 153 1000
R153 153 154 1000
R154 154 155 1000
R155 155 156 1000
R156 156 157 1000
R157 157 158 1000
R158 158 159 1000
R159 159 160 1000
R160 160 161 1000
R161 161 162 1000
R162 162 163 1000
R163 163 164 1000
R164 164 165 1000
R165 165 166 1000
R166 166 167 1000
R167 167 168 1000
R168 168 169 1000
R169 169 170 1000
R170 170 171 1000
R171 171 172 1000
R172 172 173 1000
R173 173 174 1000
R174 174 175 1000
R175 175 176 1000
R176 176 177 1000
R177 177 178 1000
R178 178 179 1000
R179 179 180 1000
R180 180 181 1000
R181 181 182 1000
R182 182 183 1000
R183 183 184 1000
R184 184 185 1000
R185 185 186 1000
R186 186 187 1000
R187 187 188 1000
R188 188 189 1000
R189 189 190 1000
R190 190 191 1000
R191 191 192 1000
R192 192 193 1000
R193 193 194 1000
R194 194 195 1000
R195 195 196 1000
R196 196 197 1000
R197 197 198 1000
R198 198 199 1000
R199 199 200 1000
R200 200 201 1000
R201 201 202 1000
R202 202 203 1000
R203 203 204 1000
R204 204 205 1000
R205 205 206 1000
R206 206 207 1000
R207 207 208 1000
R208 208 209 1000
R209 209 210 1000
R210 210 211 1000
R211 211 212 1000
R212 212 213 1000
R213 213 214 1000
R214 214 215 1000
R215 215 216 1000
R216 216 217 1000
R217 217 218 1000
R218 218 219 1000
R219 219 220 1000
R220 220 221 1000
R221 221 222 1000
R222 222 223 1000
R223 223 224 1000
R224 224 225 1000
R225 225 226 1000
R226 226 227 1000
R227 227 228 1000
R228 228 229 1000
R229 229 230 1000
R230 230 231 1000
R231 231 232 1000
R232 232 233 1000
R233 233 234 1000
R234 234 235 1000
R235 235 236 1000
R236 236 237 1000
R237 237 238 1000
R238 238 239 1000
R239 239 240 1000
R240 240 241 1000
R241 241 242 1000
R242 242 243 1000
R243 243 244 1000
R244 244 245 1000
R245 245 246 1000
R246 246 247 1000
R247 247 248 1000
R248 248 249 1000
R249 249 250 1000
R250 250 251 1000
R251 251 252 1000
R252 252 253 1000
R253 253 254 1000
R254 254 255 1000
R255 255 256 1000
R256 256 257 1000
R257 257 258 1000
R258 258 259 1000
R259 259 260 1000
R260 260 261 1000
R261 261 262 1000
R262 262 263 1000
R263 263 264 1000
R264 264 265 1000
R265 265 266 1000
R266 266 267 1000
R267 267 268 1000
R268 268 269 1000
R269 269 270 1000
R270 270 271 1000
R271 271 272 1000
R272 272 273 1000
R273 273 274 1000
R274 274 275 1000
R275 275 276 1000
R276 276 277 1000
R277 277 278 1000
R278 278 279 1000
R279 279 280 1000
R280 280 281 1000
R281 281 282 1000
R282 282 283 1000
R283 283 284 1000
R284 284 285 1000
R285 285 286 1000
R286 286 287 1000
R287 287 288 1000
R288 288 289 1000
R289 289 290 1000
R290 290 291 1000
R291 291 292 1000
R292 292 293 1000
R293 293 294 1000
R294 294 295 1000
R295 295 296 1000
R296 296 297 1000
R297 297 298 1000
R298 298 299 1000
R299 299 300 1000
R300 300 301 1000
R301 301 302 1000
R302 302 303 1000
R303 303 304 1000
R304 304 305 1000
R305 305 306 1000
R306 306 307 1000
R307 307 308 1000
R308 308 309 1000
R309 309 310 1000
R310 310 311 1000
R311 311 312 1000
R312 312 313 1000
R313 313 314 1000
R314 314 315 1000
R315 315 316 1000
R316 316 317 1000
R317 317 318 1000
R318 318 319 1000
R319 319 320 1000
R320 320 321 1000
R321 321 322 1000
R322 322 323 1000
R323 323 324 1000
R324 324 325 1000
R325 325 326 1000
R326 326 327 1000
R327 327 328 1000
R328 328 329 1000
R329 329 330 1000
R330 330 331 1000
R331 331 332 1000
R332 332 333 1000
R333 333 334 1000
R334 334 335 1000
R335 335 336 1000
R336 336 337 1000
R337 337 338 1000
R338 338 339 1000
R339 339 340 1000
R340 340 341 1000
R341 341 342 1000
R342 342 343 1000
R343 343 344 1000
R344 344 345 1000
R345 345 346 1000
R346 346 347 1000
R347 347 348 1000
R348 348 349 1000
R349 349 350 1000
R350 350 351 1000
R351 351 352 1000
R352 352 353 1000
R353 353 354 1000
R354 354 355 1000
R355 355 356 1000
R356 356 357 1000
R357 357 358 1000
R358 358 359 1000
R359 359 360 1000
R360 360 361 1000
R361 361 362 1000
R362 362 363 1000
R363 363 364 1000
R364 364 365 1000
R365 365 366 1000
R366 366 367 1000
R367 367 368 1000
R368 368 369 1000
R369 369 370 1000
R370 370 371 1000
R371 371 372 1000
R372 372 373 1000
R373 373 374 1000
R374 374 375 1000
R375 375 376 1000
R376 376 377 1000
R377 377 378 1000
R378 378 379 1000
R379 379 380 1000
R380 380 381 1000
R381 381 382 1000
R382 382 383 1000
R383 383 384 1000
R384 384 385 1000
R385 385 386 1000
R386 386 387 1000
R387 387 388 1000
R388 388 389 1000
R389 389 390 1000
R390 390 391 1000
R391 391 392 1000
R392 392 393 1000
R393 393 394 1000
R394 394 395 1000
R395 395 396 1000
R396 396 397 1000
R397 397 398 1000
R398 398 399 1000
R399 399 400 1000
R400 400 401 1000
R401 401 402 1000
R402 402 403 1000
R403 403 404 1000
R404 404 405 1000
R405 405 406 1000
R406 406 407 1000
R407 407 408 1000
R408 408 409 1000
R409 409 410 1000
R410 410 411 1000
R411 411 412 1000
R412 412 413 1000
R413 413 414 1000
R414 414 415 1000
R415 415 416 1000
R416 416 417 1000
R417 417 418 1000
R418 418 419 1000
R419 419 420 1000
R420 420 421 1000
R421 421 422 1000
R422 422 423 1000
R423 423 424 1000
R424 424 425 1000
R425 425 426 1000
R426 426 427 1000
R427 427 428 1000
R428 428 429 1000
R429 429 430 1000
R430 430 431 1000
R431 431 432 1000
R432 432 433 1000
R433 433 434 1000
R434 434 435 1000
R435 435 436 1000
R436 436 437 1000
R437 437 438 1000
R438 438 439 1000
R439 439 440 1000
R440 440 441 1000
R441 441 442 1000
R442 442 443 1000
R443 443 444 1000
R444 444 445 1000
R445 445 446 1000
R446 446 447 1000
R447 447 448 1000
R448 448 449 1000
R449 449 450 1000
R450 450 451 1000
R451 451 452 1000
R452 452 453 1000
R453 453 454 1000
R454 454 455 1000
R455 455 456 1000
R456 456 457 1000
R457 457 458 1000
R458 458 459 1000
R459 459 460 1000
R460 460 461 1000
R461 461 462 1000
R462 462 463 1000
R463 463 464 1000
R464 464 465 1000
R465 465 466 1000
R466 466 467 1000
R467 467 468 1000
R468 468 469 1000
R469 469 470 1000
R470 470 471 1000
R471 471 472 1000
R472 472 473 1000
R473 473 474 1000
R474 474 475 1000
R475 475 476 1000
R476 476 477 1000
R477 477 478 1000
R478 478 479 1000
R479 479 480 1000
R480 480 481 1000
R481 481 482 1000
R482 482 483 1000
R483 483 484 1000
R484 484 485 1000
R485 485 486 1000
R486 486 487 1000
R487 487 488 1000
R488 488 489 1000
R489 489 490 1000
R490 490 491 1000
R491 491 492 1000
R492 492 493 1000
R493 493 494 1000
R494 494 495 1000
R495 495 496 1000
R496 496 497 1000
R497 497 498 1000
R498 498 499 1000
R499 499 500 1000
R500 500 0 1000
